# Keil uVision project virtual_com_port.uvprojx, settings and files
target N32L40X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Virtual_COM_Port +hex
  AfterMake: fromelf --bin --output=.\bin\Virtual_COM_Port.bin .\Objects\Virtual_COM_Port.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,SYSCLK_FREQ=48000000
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\n32l40x_std_periph_driver\inc;..\firmware\n32l40x_usbfs_driver\inc;..\firmware\CMSIS\device;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_can.c n32l40x_comp.c n32l40x_crc.c n32l40x_dac.c n32l40x_dbg.c n32l40x_dma.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_i2c.c n32l40x_iwdg.c n32l40x_lcd.c n32l40x_lptim.c n32l40x_lpuart.c n32l40x_opamp.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_spi.c n32l40x_tim.c n32l40x_usart.c n32l40x_wwdg.c
  group USER
    ../src/: main.c n32l40x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group DOC
    ../: readme.txt
  group n32l40x_usbfs_driver
    ../firmware/n32l40x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group BSP
    ../bsp/: bsp_ltr329.c log.c
